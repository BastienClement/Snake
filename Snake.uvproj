# Keil uVision project Snake.uvproj, settings and files
target Snake (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Firmware
  c flags: Optimize=9 SizeSpeed=1
  c include: C:\Keil\C51\INC\SiLABS
  group Game
    ./src/: io.c snake.c sys.c
    ./: README.txt
